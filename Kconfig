## ion_uniphier/Kconfig
```kconfig
config ION_UNIPHIER
	tristate "Ion driver for Socionext UniPhier series."
	depends on ARCH_UNIPHIER
```
